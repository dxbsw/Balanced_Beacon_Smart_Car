# Keil uVision project LQ_F3227_Lib.uvprojx, settings and files
target LQ_F3227_Lib (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: LQ_F3227_Lib +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\APP;..\USER;..\Device;..\Device\CMSIS\KEIL_Core;..\Device\MM32F3277\HAL_Lib;..\Device\MM32F3277\HAL_Lib\Inc;..\Device\MM32F3277\HAL_Lib\Src;..\Device\MM32F3277\Include;..\Device\MM32F3277\Source;..\Device\MM32F3277\Source\KEIL_StartAsm;..\DRV;..\APP\ICM20602;..\APP\ICM20689;..\APP\ICM42605;..\APP\LQ9AX;..\APP\MPU6050;..\APP\MPU9250
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../USER/: main.c
    ../APP/: LQ_Balance.c
  group App
    ../APP/: LQ_AAConfig.h LQ_AnoScope.c LQ_AnoScope.h include.h LQ_CAMERA.c LQ_CAMERA.h LQ_GPIO_EXIT.c LQ_GPIO_EXIT.h LQ_GPIO_KEY.c LQ_GPIO_KEY.h LQ_GPIO_LED.c LQ_GPIO_LED.h LQ_ICM20689.c LQ_ICM20689.h LQ_ImageProcess.c LQ_ImageProcess.h LQ_Inductor.c LQ_Inductor.h LQ_MotorServo.c LQ_MotorServo.h LQ_MT9V034.c LQ_MT9V034.h LQ_OLED096.c LQ_OLED096.h LQ_PID.c LQ_PID.h LQ_TFT18.c LQ_TFT18.h LQ_TFT18Pic.h 用户可以在此文件夹添加自己的文件.txt
    ../APP/MPU6050/: LQ_demo_DMP.c LQ_MPU6050_DMP.h LQ_MPU6050_DMP.lib LQ_I2C_MPU6050.c LQ_I2C_MPU6050.h
    ../APP/MPU9250/: LQ_I2C_MPU9250.c LQ_I2C_MPU9250.h
  group system
    ../Device/MM32F3277/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
    ../Device/MM32F3277/Source/: system_mm32f327x.c
  group Hal
    ../Device/MM32F3277/HAL_Lib/Inc/: dtype.h hal_adc.h hal_bkp.h hal_can.h hal_comp.h hal_conf.h hal_crc.h hal_crs.h hal_dac.h hal_dbg.h hal_device.h hal_dma.h hal_eth.h hal_eth_conf.h hal_exti.h hal_flash.h hal_fsmc.h hal_gpio.h hal_i2c.h hal_iwdg.h hal_misc.h hal_pwr.h hal_rcc.h hal_redefine.h hal_rtc.h hal_sdio.h hal_spi.h hal_syscfg.h hal_tim.h hal_uart.h hal_uid.h hal_ver.h hal_wwdg.h
    ../Device/MM32F3277/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group DRV
    ../DRV/: LQ_ADC.c LQ_ADC.h LQ_DMA.c LQ_DMA.h LQ_Encoder.c LQ_Encoder.h LQ_FLASH.c LQ_FLASH.h LQ_GPIO.c LQ_GPIO.h LQ_I2C.c LQ_I2C.h LQ_PWM.c LQ_PWM.h LQ_SOFTI2C.c LQ_SOFTI2C.h LQ_SOFTSPI.c LQ_SOFTSPI.h LQ_SPI.c LQ_SPI.h LQ_SYS.c LQ_SYS.h LQ_TIMER.c LQ_TIMER.h LQ_UART.c LQ_UART.h
